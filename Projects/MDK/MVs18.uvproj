# Keil uVision project MVs18.uvproj, settings and files
target MVs18 (ARM-ADS)
  device: Cortex-M3 ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M3") ESEL ELITTLE
  output: MVs18
  AfterMake: fromelf.exe --bin -o "#L.bin" "#L"
  c flags: Optim=1 OneElfS=1
  c define: __CORTEX_M3, __CC_ARM
  c misc: --gnu
  c include: ..\..\Driver\driver\inc;..\..\MiddleWare\Audio\inc;..\..\MiddleWare\Bluetooth\inc;..\..\MiddleWare\CharacterEncoding\inc;..\..\MiddleWare\FS\inc;..\..\MiddleWare\MVUtils\inc;..\..\MiddleWare\OS;..\..\MiddleWare\OS\FreeRTOS\Source\include;..\..\MiddleWare\OS\FreeRTOS\Source\portable\RVDS\ARM_CM3;..\..\MiddleWare\User\inc;..\..\MiddleWare\FlashFS\INCLUDE;..\Inc;..\..\MiddleWare\Wifi\host;..\..\MiddleWare\Wifi\host\include;..\..\MiddleWare\Wifi\host\include\priv;..\..\MiddleWare\Wifi\host\include\priv\hw;..\..\MiddleWare\Wifi\host\os_wrapper\freeRTOS;..\..\MiddleWare\Wifi\host\platform\mvsilicon;..\..\MiddleWare\Wifi\host\app;..\..\MiddleWare\Wifi\host\app\cli;..\..\MiddleWare\Wifi\host\drv;..\..\MiddleWare\Wifi\host\drv\sdio;..\..\MiddleWare\Wifi\host\ap;..\..\MiddleWare\Wifi\host\ap\common;..\..\MiddleWare\Wifi\host\tcpip\lwip-1.4.0\src\include;..\..\MiddleWare\Wifi\host\tcpip\lwip-1.4.0\src\include\lwip;..\..\MiddleWare\Wifi\host\tcpip\lwip-1.4.0\ports\icomm;..\..\MiddleWare\Wifi\host\tcpip\lwip-1.4.0\ports\icomm\include;..\..\MiddleWare\Wifi\host\tcpip\lwip-1.4.0\src\include\ipv4;..\..\MiddleWare\Wifi\host\app\netapp;..\..\MiddleWare\Wifi\host\app\netapp\udhcp;..\..\MiddleWare\Wifi\host\app\netmgr;..\..\MiddleWare\Wifi\host\app\netmgr\SmartConfig;..\..\MiddleWare\Wifi\host\app\netmgr\SmartConfig\iComm\core;..\..\MiddleWare\Wifi\host\app\netapp\iperf3.0\src;..\..\MiddleWare\Wifi\host\core;..\..\MiddleWare\Wifi\host\netstack_wrapper\icomm_lwIP;..\..\MiddleWare\Wifi\mvs;..\..\MiddleWare\WxCloud;..\..\MiddleWare\FlashFS;..\..\MiddleWare\Wifi\inc;..\..\MiddleWare\OS\shell
  scatter file: .\MVs18.sct
  link misc: --keep *.o(.mach*.init)  --keep *.o(.shell*.cmd)  --keep *.o(.notify*.init)  --keep *.o(.sched.stub*) --keep *.o(.driver*.isr) --keep *.o(CACHE.4KBMEM)
--diag_suppress=L6314W,L6319W
  group Driver
    ../../Driver/driver/: sd_spi.c
  group Middleware/FlashFS
    ../../MiddleWare/FlashFS/: file.c Flash.c access_flash.c
  group Middleware/FS
    ../../MiddleWare/FS/src/: diskio.c filesort.c partition.c presearch.c
  group Middleware/MVUtils
    ../../MiddleWare/MVUtils/src/: mv_list.c mv_ring_buffer.c
  group Middleware/OS
    ../../MiddleWare/OS/: rtos_api.c
    ../../MiddleWare/OS/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../../MiddleWare/OS/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
    ../../MiddleWare/OS/FreeRTOS/Source/portable/MemMang/: heap_5s.c heap_5.c
    ../../MiddleWare/OS/shell/: shell.c
  group Middleware/User
    ../../MiddleWare/User/src/: device_detect.c key.c power.c storage.c system_info.c tip_sound.c battery.c
  group Middleware/Wifi
    ../../MiddleWare/Wifi/host/app/cli/cmds/: cli_cmd.c cli_cmd_net.c cli_cmd_wifi.c cli_cmd_sys.c cli_cmd_soc.c cli_cmd_rf_test.c
    ../../MiddleWare/Wifi/host/app/cli/: cli.c cli_key.c
    ../../MiddleWare/Wifi/host/app/netapp/ping/: ping.c
    ../../MiddleWare/Wifi/host/app/netapp/: net_app.c
    ../../MiddleWare/Wifi/host/os_wrapper/FreeRTOS/: rtos.c rtos_glue.c
    ../../MiddleWare/Wifi/host/platform/mvsilicon/: porting.c sdio_port.c
    ../../MiddleWare/Wifi/host/tcpip/lwip-1.4.0/ports/icomm/: sys_arch.c
    ../../MiddleWare/Wifi/host/tcpip/lwip-1.4.0/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../../MiddleWare/Wifi/host/tcpip/lwip-1.4.0/src/core/: def.c dhcp.c dns.c inet_chksum.c lwip_init.c lwip_pbuf.c lwip_timers.c mem.c memp.c netif.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c udp.c
    ../../MiddleWare/Wifi/host/tcpip/lwip-1.4.0/src/core/ipv4/: autoip.c icmp.c igmp.c ip_frag.c ip4.c ip4_addr.c
    ../../MiddleWare/Wifi/host/tcpip/lwip-1.4.0/src/netif/: etharp.c ethernetif.c slipif.c
    ../../MiddleWare/Wifi/host/: init.c macaddr.c ssv_frame.c
    ../../MiddleWare/Wifi/host/app/netapp/httpserver_raw/: httpd.c httpd_cgi_ssi.c fs.c
    ../../MiddleWare/Wifi/lib/: ssv_wifi.lib
    ../../MiddleWare/Wifi/host/netstack_wrapper/icomm_lwIP/: netstack.c
    ../../MiddleWare/Wifi/mvs/: resource_wifi_fw.s sdcard.c
    ../../MiddleWare/Wifi/src/: wifi_api.c wifi_porting.c wifi_audio_api.c
  group Middleware/WxCloud
    ../../MiddleWare/WxCloud/: libwxcloud.lib wxcloud_porting.c wxcloud_api.c
  group Projects/Apps
    ../Apps/BluetoothApp/: bt_audio_play.c
    ../Apps/MainApp/: app_mode.c main_app.c
    ../Apps/WifiAudioApp/: wifi_audio_play.c
    ../Apps/MediaApp/: media_audio_play.c
  group Projects/Main
    ../Main/: main.c retarget.c startup.c
  group Projects/Platform
    ../Platform/Bluetooth/: bluetooth_interface.c bt_ddb_flash.c bt_ddb_interface.c bt_os_interface.c bt_trust_list.c bt_uart_interface.c
    ../Platform/Key/: key_interface.c
    ../Platform/Device Detect/: device_detect_interface.c
    ../Platform/Battery/: battery_interface.c
  group Projects/Services
    ../Services/AudioCoreService/: audio_core_service.c
    ../Services/BluetoothService/: bluetooth_service.c
    ../Services/DeviceService/: device_service.c
    ../Services/WifiService/: wifi_service.c
    ../Services/WxService/: wxcloud_service.c
    ../Services/DecoderService/: decoder_service.c
    ../Services/MediaService/: media_service.c
    ../Services/: wifi_audio_service.c
    ../Services/WxSpeechService/: wx_speech_service.c
  group Services/AudioCore
    ../Services/AudioCoreService/: audio_core_aec.c audio_core_mix.c audio_core.c audio_core_prot.c
  group libs
    ../../Driver/driver/: driver.lib
    ../../MiddleWare/Bluetooth/: bt.lib
    ../../MiddleWare/CharacterEncoding/: character_encoding.lib
    ../../MiddleWare/FS/: fs.lib
    ../../MiddleWare/Audio/: adpcm_encoder.lib audio_bluetooth.lib audio_decoder.lib audio_encoder.lib audio_utility.lib dc_blocker.lib drc.lib echo.lib libmp3enc.lib silence_detector.lib sra.lib three_d.lib virtual_bass.lib
